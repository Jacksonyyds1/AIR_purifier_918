# Keil uVision project template.uvprojx, settings and files
target AIR_Purifer_918 (6210000::V6.21::ARMCLANG)
  device: -AT32F403ZGT6 ArteryTek
  pack: ArteryTek.AT32F403_DFP.2.1.3
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F403ZGT6,USE_STDPERIPH_DRIVER,AT_START_F403_V1
  c include: ..\inc;..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\at32f403_board;..\..\libraries\timer_envent;..\iHastek\inc;..\..\libraries\absolute_encoder
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403_clock.c at32f403_int.c main.c led_control.c logger.c
  group bsp
    ../at32f403_board/: at32f403_board.c
    ../bsp/: multi_button.c
  group firmware
    ../../libraries/drivers/src/: at32f403_adc.c at32f403_bpr.c at32f403_can.c at32f403_crc.c at32f403_crm.c at32f403_dac.c at32f403_debug.c at32f403_dma.c at32f403_exint.c at32f403_flash.c at32f403_gpio.c at32f403_i2c.c at32f403_misc.c at32f403_pwc.c at32f403_rtc.c at32f403_sdio.c at32f403_spi.c at32f403_tmr.c at32f403_usart.c at32f403_usb.c at32f403_wdt.c at32f403_wwdt.c at32f403_xmc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f403.c
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403.s
  group iHastek
    ../../libraries/timer_envent/: TimeEvent.c
